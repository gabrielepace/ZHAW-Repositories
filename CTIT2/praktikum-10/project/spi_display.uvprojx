# Keil uVision project spi_display.uvprojx, settings and files
target SPI_Display (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CT_Board_HS14_M0 STMicroelectronics
  pack: InES.CTBoard14_DFP.4.0.2
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(180000000) ELITTLE
  output: spi_display
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: MOCKED_SPI_DISPLAY
  c misc: -D SMOCKED_SPI_DISPLAY
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress 6314
  group Source SPI-Display
    ./app/: lcd_io.c cmd_lcd.c hal_spi.c cmd_touch.c hal_mocked.c hal_sbuf.c main.c
software components: CMSIS:CORE 5.1.2, Device:Startup 4.0.1, HAL:FMC 3.0.1, HAL:GPIO 4.0.1, HAL:PWR 2.2.0, HAL:RCC 4.0.1
